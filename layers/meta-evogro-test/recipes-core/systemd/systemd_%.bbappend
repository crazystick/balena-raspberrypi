PACKAGECONFIG ??= "sysusers lz4 kmod networkd resolved timesyncd timedated hostnamed"
